# Keil uVision project STM32F4xx.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: STM32F4xx,STM32F407xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\..\..\mcuLib\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\mcuLib\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\mcuLib\STM32F4xx;..\..\..\rt-thread\include;..\..\STM32F4XX_spark;..\..\..\ebox\core;..\..\..\ebox\core\stm32;..\..\..\ebox\core\LinkedList;..\..\..\ebox\interface;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\Wire\src;..\..\..\component\edriver;..\..\..\ebox\hardware\STM32F4xx\Peripherals;..\..\..\ebox\hardware\STM32F4xx;..\..\..\ebox\core\stm32;..\..\..\component;..\..\..\component\rtt;..\app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../mcuLib/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../../../mcuLib/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group rtt
    ../../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.s cpuport.c
    ../../../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group core
    ../../../ebox/core/: ebox_core.cpp big_little.c crc.c fifo.c itoa.c Dstring.cpp ebox_math.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/Wire/src/: twi.c Wire.cpp
    ../../../ebox/interface/: hmi.cpp
  group ebox_mcu
    ../../../ebox/hardware/STM32F4xx/: rcc.cpp nvic.cpp ebox_it.cpp objects.cpp
    ../../../ebox/hardware/STM32F4xx/Peripherals/: ebox_gpio.cpp ebox_wdg.cpp ebox_uart.cpp ebox_mcu_spi.cpp ebox_mcu_i2c.cpp ebox_timer.cpp ebox_adc.cpp
  group component
    ../../../component/rtt/: cpu_usage.cpp cmd_easy.cpp rtt_utils.cpp
    ../../../component/configLoader/: configLoader.cpp
  group driver
    ../../../component/edriver/: 74HC595.cpp at24x.cpp w25xxx.cpp mmc_sd.cpp
    ../../../component/font/: fonts.c
    ../../../component/lcd/: bsp_nt35510_lcd.c
    ../../../component/camera/: bsp_ov2640.c bsp_i2c.c
  group user
    ../: main.cpp bsp_ebox.cpp board.c rtconfig.h stm32f4xx_hal_msp.c stm32f4xx_it.c testData.cpp
  group user/app
    ../app/: app1.cpp app2.cpp app3.cpp
  group vfs
    ../../../ebox/interface/storage/blockdevice/: ebox_block.cpp
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileBase.cpp FileHandle.cpp FileSystem.cpp FileSystemHandle.cpp
  group lfs
    ../../../ebox/interface/storage/filesystem/littlefs/: LittleFileSystem.cpp
    ../../../ebox/interface/storage/filesystem/littlefs/littlefs/: lfs.c lfs_util.c
  group ffs
    ../../../ebox/interface/storage/filesystem/fat/: FATFileSystem.cpp
    ../../../ebox/interface/storage/filesystem/fat/ChaN/: ff.cpp ffunicode.cpp
software components: CMSIS:CORE 5.6.0
