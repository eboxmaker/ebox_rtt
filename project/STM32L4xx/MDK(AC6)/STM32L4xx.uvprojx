# Keil uVision project STM32L4xx.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L451VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L4xx +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L451xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ..\..\..\mcuLib\Drivers\CMSIS\Include;..\..\..\mcuLib\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\mcuLib\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\mcuLib\STM32L4xx;..\..\..\rt-thread\include;..\..\STM32L4XX;..\..\..\ebox;..\..\..\ebox\core;..\..\..\ebox\interface;..\..\..\ebox\core\stm32;..\..\..\component\edriver;..\..\..\ebox\hardware\STM32L4xx\Peripherals;..\..\..\ebox\hardware\STM32L4xx;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\Wire\src;..\..\..\ebox\interface\spi;..\..\..\ebox\interface\DateTime;..\..\..\component;..\..\..\component\rtt;..\..\..\component\apps\Filters;..\app;..\..\..\mcuLib\STM32L4xx;..\..\..\component\edriver;..\..\..\component\modbus\libraries\Modbus;..\..\..\component\modbus\libraries\ModbusSerial;..\..\..\component\ADS1120;..\..\..\component\TinyGPSPlus\src;..\..\..\component\apps\ripple;..\mb;..\..\..\component\cJSON-1.7.15
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group CMSIS
    ../../../mcuLib/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l451xx.s
    ../: system_stm32l4xx.c
  group STM32L4xx_HAL_Driver
    ../../../mcuLib/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group rtt
    ../../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.s cpuport.c
    ../../../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group core
    ../../../ebox/core/: ebox_core.cpp big_little.c crc.c fifo.c itoa.c Dstring.cpp ebox_math.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/: hmi.cpp
    ../../../ebox/interface/Wire/src/: twi.c
    ../../../ebox/interface/DateTime/: DateTime.cpp BasicRtc.cpp RtcMillis.cpp calendar.cpp
  group ebox_mcu
    ../../../ebox/hardware/STM32L4xx/: rcc.cpp nvic.cpp ebox_it.cpp objects.cpp
    ../../../ebox/hardware/STM32L4xx/Peripherals/: ebox_gpio.cpp ebox_uart.cpp ebox_timer.cpp ebox_mcu_spi.cpp ebox_mcu_i2c.cpp ebox_adc.cpp ebox_wdg.cpp ebox_flash.cpp ebox_rtc.cpp
  group component
    ../../../component/rtt/: cpu_usage.cpp cmd_easy.cpp rtt_utils.cpp
    ../../../component/configLoader/: configLoader.cpp
    ../../../component/linearRegression/: Linear.cpp LinearRegression.cpp LinearPiecewise.cpp
    ../../../component/apps/ripple/: ripple.cpp
  group driver
    ../../../component/edriver/: 74HC595.cpp at24x.cpp mmc_sd.cpp w25xxx.cpp sdio.cpp 4g.cpp
    ../../../component/ADS1120/: ADS1120.cpp
    ../../../component/TinyGPSPlus/src/: TinyGPS++.cpp
    ../: relay.cpp power.cpp
  group user
    ../: main.cpp bsp_ebox.cpp board.c rtconfig.h stm32l4xx_it.c stm32l4xx_hal_msp.c mqtt.cpp bsp_rtc.cpp analog_ch.cpp analog_bat.cpp log.cpp low_power.cpp
  group user/mb
    ../mb/: modbus_addr.cpp calibration.cpp config.cpp runValue.cpp serverConfig.cpp ThreholdesConfig.cpp dev.cpp
  group user/app
    ../app/: app.cpp app_mb.cpp app_adc.cpp app_regu.cpp app_cont.cpp app_test.cpp app_calibration.cpp app_mqtt.cpp app_utils.cpp app_gps.cpp app_history.cpp app_save.cpp
  group VFS
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileBase.cpp FileHandle.cpp FileSystem.cpp FileSystemHandle.cpp
    ../../../ebox/interface/storage/filesystem/fat/: FATFileSystem.cpp
    ../../../ebox/interface/storage/filesystem/fat/ChaN/: ff.cpp ffunicode.cpp
  group modbus
    ../../../component/modbus/libraries/ModbusSerial/: ModbusSerial.cpp
    ../../../component/modbus/libraries/Modbus/: Modbus.cpp
  group json
    ../../../component/cJSON-1.7.15/: cJSON.c
software components: CMSIS:CORE 5.6.0
