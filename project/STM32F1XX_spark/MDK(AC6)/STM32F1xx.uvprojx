# Keil uVision project STM32F1xx.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1xx +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xB,USE_FULL_LL_DRIVER,STM32F1xx
  c include: ..\..\..\mcuLib\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\mcuLib\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\mcuLib\STM32F1xx;..\..\..\rt-thread\include;..\..\STM32F1XX_spark;..\..\..\ebox;..\..\..\ebox\core;..\..\..\ebox\core\LinkedList;..\..\..\ebox\interface;..\..\..\ebox\interface\i2c;..\..\..\ebox\interface\spi;..\..\..\component\edriver;..\..\..\ebox\hardware\STM32F1xx\Peripherals;..\..\..\ebox\hardware\STM32F1xx;..\..\..\ebox\core\stm32;..\..\..\component\Ethernet3;..\..\..\component\Ethernet3\utility;..\..\..\component\rtt;..\app;..\..\..\ebox\interface\Wire\src;..\..\..\ebox\interface;..\..\..\component\cJSON
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../mcuLib/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    ../: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../../../mcuLib/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group rtt
    ../../../rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../../../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group core
    ../../../ebox/core/: ebox_core.cpp big_little.c crc.c fifo.c itoa.c Dstring.cpp ebox_math.cpp IPAddress.cpp new.cpp print.cpp ringbuf.cpp sort.cpp Stream.cpp WString.cpp
    ../../../ebox/core/LinkedList/: LinkedList.h
  group interface
    ../../../ebox/interface/i2c/: soft_i2c.cpp i2c.cpp
    ../../../ebox/interface/spi/: soft_spi.cpp
    ../../../ebox/interface/Wire/src/: twi.c Wire.cpp
  group ebox_mcu
    ../../../ebox/hardware/STM32F1xx/: rcc.cpp nvic.cpp ebox_it.cpp objects.cpp
    ../../../ebox/hardware/STM32F1xx/Peripherals/: ebox_adc.cpp ebox_gpio.cpp ebox_uart.cpp ebox_mcu_spi.cpp ebox_mcu_i2c.cpp ebox_timer.cpp ebox_iflash.cpp ebox_wdg.cpp
  group component
    ../../../component/rtt/: cpu_usage.cpp cmd_easy.cpp rtt_utils.cpp
    ../../../component/configLoader/: configLoader.cpp
  group driver
    ../../../component/edriver/: 74HC595.cpp at24x.cpp mmc_sd.cpp w25xxx.cpp
  group net
    ../../../component/Ethernet3/utility/: socket.cpp w5500.cpp
    ../../../component/Ethernet3/: Dhcp.cpp Dns.cpp Ethernet3.cpp EthernetClient.cpp EthernetServer.cpp EthernetUdp3.cpp
  group user
    ../: stm32f1xx_hal_msp.c stm32f1xx_it.c main.cpp bsp_ebox.cpp board.c rtconfig.h
  group user/app
    ../app/: app1.cpp app2.cpp
  group vfs
    ../../../ebox/interface/storage/filesystem/: Dir.cpp File.cpp FileBase.cpp FileHandle.cpp FileSystem.cpp FileSystemHandle.cpp
    ../../../ebox/interface/storage/filesystem/fat/: FATFileSystem.cpp
    ../../../ebox/interface/storage/filesystem/fat/ChaN/: ff.cpp ffunicode.cpp
  group json
    ../../../component/cJSON-1.7.15/: cJSON.c
software components: CMSIS:CORE 5.6.0
